# IAR project Project.ewp, settings and files
configuration STM32F429_439xx (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
configuration STM32F427_437xx (ARM, debug)
  as the first configuration, except:
configuration STM32F40_41xxx (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F40XX; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..; ..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\Libraries\CMSIS\Include; ..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  OBJCOPY.OOCOutputFile: Project.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F401xx (ARM, debug)
  as the first configuration, except:
configuration STM32F411xE (ARM, debug)
  as the first configuration, except:
configuration STM32F446xx (ARM, debug)
  as the first configuration, except:
configuration STM32F469_479xx (ARM, debug)
  as the first configuration, except:
configuration STM32F410xx (ARM, debug)
  as the first configuration, except:
configuration STM32F412xG (ARM, debug)
  as the first configuration, except:
configuration STM32F413_423xx (ARM, debug)
  as the first configuration, except:
  group CMSIS
    ../: system_stm32f4xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f401xx.s startup_stm32f40_41xxx.s startup_stm32f410xx.s startup_stm32f411xe.s startup_stm32f412xg.s startup_stm32f413_423xx.s startup_stm32f427_437xx.s startup_stm32f429_439xx.s startup_stm32f446xx.s startup_stm32f469_479xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../: main.c stm32f4xx_it.c
